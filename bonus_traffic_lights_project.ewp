# IAR project bonus_traffic_lights_project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123FH6PM TexasInstruments TM4C123FH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: bitwise_operation.h cstartup_M.c DIO.c DIO.h GPIOF_interrupt.c GPIOF_interrupt.h gptm_timer_interrupts.c gptm_timer_interrupts.h main.c tm4c123gh6pm.h traffic_lights_sequence.c traffic_lights_sequence.h
